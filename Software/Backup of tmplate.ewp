# IAR project Backup of tmplate.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; Libraries\CMSIS\CM3\CoreSupport; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; Libraries\STM32F10x_StdPeriph_Driver\inc; Libraries\STM32F10x_StdPeriph_Driver\src; USER
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tmplate.srec
  ILINK.IlinkOutputFile: tmplate.out
  ILINK.IlinkIcfFile: link\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Drivers
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    USER/: delay.c i2c_ee.c remote.c USART.c
    ./: main.c stm32f10x_it.c
